Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2020-06-09T13:23:37
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Jun 09 13:23:37 2020 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{6408C7A4-1321-43BE-AD8B-075840950351}\ifc * Database version: 5507 * Database creation date: Tue Jun 09 13:23:35 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Jun 09 13:23:36 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Jun 09 13:23:36 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 1039 Kitchen faucet with dishwasher valve, 1039(2020):1039 Kitchen faucet with dishwasher valve:329417
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions(Type) - InletConnectionSize: 10 mm; Projection: 178 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: 1039(2020); ConvergoRefNr: 0087-1803-0013-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for sinks; NBSReference: 45-35-70/345; ProductInformation: Kitchen faucet with high spout and dishwasher valve with ceramic cartridge 90° rotation for ON/OFF; Revision: 1; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Sink manual water supply sets; Uniclass2015Reference: Pr_40_20_87_82; Version: 2; VersionDate: 01/05/2020
Type - Green Building Properties(Type) - Approval KIWA SE Type Approval: 1491; Backflow Prevention EN1717: AA; Customs Code: 84818011; EAN Number: 6414150078941; EN Standard: EN 817; LVI Number: 6219122; STF Certificate: VTT-RTH-00090-17; URL KIWA SE Type Approval: http://static.oras.com/SETypeApproval/1039; URL STF: http://static.oras.com/STF/1039; VVS Number: 705898304
Type - Identity Data(Type) - 2D/3D/BIM Files URL: http://static.oras.com/bim/1039; Catalog Drawing URL: http://static.oras.com/catdrw/1039; Class: Single lever; Dimension Drawing URL: http://static.oras.com/dimdrw/1039; FDV Document URL: http://www.oras.com/datasheet/1039/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/1039; Group: Kitchen faucets; Long Marketing: Kitchen faucet with high spout and dishwasher valve with ceramic cartridge 90° rotation for ON/OFF. Swivel spout and aerator. Spout’s swing angle is factory preset at 120° (can be limited to 0° or 60° ). The spout can be fixed in position on the left or right or at the back of the faucet. There are also in-built limitation options for water temperature and maximum flow-rate.; Manufacturer: Oras; Market: INT;FIN;POL;RUS;EST;LTU;LVA;UKR; Model: 1039 Kitchen faucet with dishwasher valve; Name_en: 1039 Kitchen faucet with dishwasher valve; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 754 x 334 x 63; Package Weight: 2.21 kg; Product Code: 1039; Product Datasheet: http://www.oras.com/datasheet/1039/en; Product Family: Oras Safira; Product Image URL: http://static.oras.com/image/1039; Product URL: http://static.oras.com/1039; Type Name: 1039 Kitchen faucet with dishwasher valve
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Advanced Features: 3S-Installation; Connection Size: Ø10 mm; Dishwasher Valve: Dishwasher valve; Flow Rate At 300kPa: 0.00953496 m3/s; Installation and Maintenance: http://static.oras.com/manual/1039; Installation Type: Deck mounted; Lever Handle: Lever with H+C symbol; Max. Hot Water Supply: 80 kg/K/s3; Mechanical Parts: 40Cartridge; Mounting Holes: 1 Mounting Hole; Noise Class: I (ISO 3822); Pressure Loss With Flow 02ls: 160000 Pa; Spare Parts: http://static.oras.com/sp/1039; Spout Swivel Range: 120° (60° / 0°); Spout Type: Swivel spout; Temperature: Temperature limiter
Type - Other(Type) - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 1039(2020); Features: Single lever; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 1039; Name: 1039 Kitchen faucet with dishwasher valve; ReplacementCost: n/a; Shape: Sculptured; Size: 55x260x340 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 1039; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 1039 Kitchen faucet with dishwasher valve
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.12186 m2; Volume: 0.00477761 m3
Identity Data - Mark: 6
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 1039(2020): 1039 Kitchen faucet with dishwasher valve; Family and Type: 1039(2020): 1039 Kitchen faucet with dishwasher valve; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 1039(2020): 1039 Kitchen faucet with dishwasher valve; Type Id: 1039(2020): 1039 Kitchen faucet with dishwasher valve; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
